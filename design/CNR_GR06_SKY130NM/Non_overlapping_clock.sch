v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Non overlapping clock} -280 -580 0 0 1 1 {}
N -670 -470 -620 -470 {
lab=VDD_1V8}
N -730 410 -670 410 {
lab=VSS}
N -670 -190 -650 -190 {
lab=Clk}
N -670 -190 -670 -80 {
lab=Clk}
N -670 -80 -650 -80 {
lab=Clk}
N -610 -160 -590 -160 {
lab=#net1}
N -590 -160 -590 -110 {
lab=#net1}
N -610 -110 -590 -110 {
lab=#net1}
N -610 -220 -590 -220 {
lab=VDD_1V8}
N -590 -220 -590 -190 {
lab=VDD_1V8}
N -610 -190 -590 -190 {
lab=VDD_1V8}
N -610 -80 -590 -80 {
lab=VSS}
N -590 -80 -590 -50 {
lab=VSS}
N -610 -50 -590 -50 {
lab=VSS}
N -410 -390 -330 -390 {
lab=#net2}
N -370 -390 -370 -360 {
lab=#net2}
N -370 -300 -370 -270 {
lab=#net3}
N -390 -240 -370 -240 {
lab=VSS}
N -390 -240 -390 -210 {
lab=VSS}
N -390 -210 -370 -210 {
lab=VSS}
N -370 -330 -350 -330 {
lab=#net3}
N -350 -330 -350 -290 {
lab=#net3}
N -370 -290 -350 -290 {
lab=#net3}
N -410 -450 -330 -450 {
lab=VDD_1V8}
N -410 -420 -330 -420 {
lab=VDD_1V8}
N -410 -420 -370 -420 {
lab=VDD_1V8}
N -370 -450 -370 -420 {
lab=VDD_1V8}
N -370 -470 -370 -450 {
lab=VDD_1V8}
N -330 -240 -210 -240 {
lab=#net4}
N -290 -420 -280 -420 {
lab=#net4}
N -280 -420 -280 -240 {
lab=#net4}
N -370 -380 -200 -380 {
lab=#net2}
N -470 -420 -450 -420 {
lab=Clk}
N -470 -420 -470 -330 {
lab=Clk}
N -470 -330 -410 -330 {
lab=Clk}
N -520 -400 -470 -400 {
lab=Clk}
N -710 -400 -520 -400 {
lab=Clk}
N -700 -400 -700 -140 {
lab=Clk}
N -700 -140 -670 -140 {
lab=Clk}
N -410 120 -330 120 {
lab=#net5}
N -370 120 -370 150 {
lab=#net5}
N -370 210 -370 240 {
lab=#net6}
N -390 270 -370 270 {
lab=VSS}
N -390 270 -390 300 {
lab=VSS}
N -390 300 -370 300 {
lab=VSS}
N -370 180 -350 180 {
lab=#net6}
N -350 180 -350 220 {
lab=#net6}
N -370 220 -350 220 {
lab=#net6}
N -410 60 -330 60 {
lab=VDD_1V8}
N -410 90 -330 90 {
lab=VDD_1V8}
N -410 90 -370 90 {
lab=VDD_1V8}
N -370 60 -370 90 {
lab=VDD_1V8}
N -370 40 -370 60 {
lab=VDD_1V8}
N -330 270 -210 270 {
lab=#net7}
N -290 90 -280 90 {
lab=#net7}
N -280 90 -280 270 {
lab=#net7}
N -370 130 -200 130 {
lab=#net5}
N -470 90 -450 90 {
lab=#net1}
N -470 90 -470 180 {
lab=#net1}
N -470 180 -410 180 {
lab=#net1}
N -590 -130 -520 -130 {
lab=#net1}
N -520 -130 -520 140 {
lab=#net1}
N -520 140 -470 140 {
lab=#net1}
N -140 -430 -120 -430 {
lab=#net2}
N -140 -430 -140 -320 {
lab=#net2}
N -140 -320 -120 -320 {
lab=#net2}
N -80 -400 -60 -400 {
lab=#net8}
N -60 -400 -60 -350 {
lab=#net8}
N -80 -350 -60 -350 {
lab=#net8}
N -80 -460 -60 -460 {
lab=VDD_1V8}
N -60 -460 -60 -430 {
lab=VDD_1V8}
N -80 -430 -60 -430 {
lab=VDD_1V8}
N -80 -320 -60 -320 {
lab=VSS}
N -60 -320 -60 -290 {
lab=VSS}
N -80 -290 -60 -290 {
lab=VSS}
N -170 -380 -140 -380 {
lab=#net2}
N -60 -370 10 -370 {
lab=#net8}
N 40 -420 60 -420 {
lab=#net8}
N 40 -420 40 -310 {
lab=#net8}
N 40 -310 60 -310 {
lab=#net8}
N 100 -390 120 -390 {
lab=#net9}
N 120 -390 120 -340 {
lab=#net9}
N 100 -340 120 -340 {
lab=#net9}
N 100 -450 120 -450 {
lab=VDD_1V8}
N 120 -450 120 -420 {
lab=VDD_1V8}
N 100 -420 120 -420 {
lab=VDD_1V8}
N 100 -310 120 -310 {
lab=VSS}
N 120 -310 120 -280 {
lab=VSS}
N 100 -280 120 -280 {
lab=VSS}
N 10 -370 40 -370 {
lab=#net8}
N 120 -360 190 -360 {
lab=#net9}
N 220 -410 240 -410 {
lab=#net9}
N 220 -410 220 -300 {
lab=#net9}
N 220 -300 240 -300 {
lab=#net9}
N 280 -380 300 -380 {
lab=#net10}
N 300 -380 300 -330 {
lab=#net10}
N 280 -330 300 -330 {
lab=#net10}
N 280 -440 300 -440 {
lab=VDD_1V8}
N 300 -440 300 -410 {
lab=VDD_1V8}
N 280 -410 300 -410 {
lab=VDD_1V8}
N 280 -300 300 -300 {
lab=VSS}
N 300 -300 300 -270 {
lab=VSS}
N 280 -270 300 -270 {
lab=VSS}
N 190 -360 220 -360 {
lab=#net9}
N -170 80 -150 80 {
lab=#net5}
N -170 80 -170 190 {
lab=#net5}
N -170 190 -150 190 {
lab=#net5}
N -110 110 -90 110 {
lab=#net11}
N -90 110 -90 160 {
lab=#net11}
N -110 160 -90 160 {
lab=#net11}
N -110 50 -90 50 {
lab=VDD_1V8}
N -90 50 -90 80 {
lab=VDD_1V8}
N -110 80 -90 80 {
lab=VDD_1V8}
N -110 190 -90 190 {
lab=VSS}
N -90 190 -90 220 {
lab=VSS}
N -110 220 -90 220 {
lab=VSS}
N -200 130 -170 130 {
lab=#net5}
N -90 140 -20 140 {
lab=#net11}
N 10 90 30 90 {
lab=#net11}
N 10 90 10 200 {
lab=#net11}
N 10 200 30 200 {
lab=#net11}
N 70 120 90 120 {
lab=#net12}
N 90 120 90 170 {
lab=#net12}
N 70 170 90 170 {
lab=#net12}
N 70 60 90 60 {
lab=VDD_1V8}
N 90 60 90 90 {
lab=VDD_1V8}
N 70 90 90 90 {
lab=VDD_1V8}
N 70 200 90 200 {
lab=VSS}
N 90 200 90 230 {
lab=VSS}
N 70 230 90 230 {
lab=VSS}
N -20 140 10 140 {
lab=#net11}
N 1500 100 1520 100 {
lab=#net4}
N 1500 100 1500 210 {
lab=#net4}
N 1500 210 1520 210 {
lab=#net4}
N 1560 130 1580 130 {
lab=Clk_2}
N 1580 130 1580 180 {
lab=Clk_2}
N 1560 180 1580 180 {
lab=Clk_2}
N 1560 70 1580 70 {
lab=VDD_1V8}
N 1580 70 1580 100 {
lab=VDD_1V8}
N 1560 100 1580 100 {
lab=VDD_1V8}
N 1560 210 1580 210 {
lab=VSS}
N 1580 210 1580 240 {
lab=VSS}
N 1560 240 1580 240 {
lab=VSS}
N -200 -380 -170 -380 {
lab=#net2}
N -210 270 290 270 {
lab=#net7}
N -210 -240 180 -240 {
lab=#net4}
N 1490 -410 1510 -410 {
lab=#net7}
N 1490 -410 1490 -300 {
lab=#net7}
N 1490 -300 1510 -300 {
lab=#net7}
N 1550 -380 1570 -380 {
lab=Clk_1}
N 1570 -380 1570 -330 {
lab=Clk_1}
N 1550 -330 1570 -330 {
lab=Clk_1}
N 1550 -440 1570 -440 {
lab=VDD_1V8}
N 1570 -440 1570 -410 {
lab=VDD_1V8}
N 1550 -410 1570 -410 {
lab=VDD_1V8}
N 1550 -300 1570 -300 {
lab=VSS}
N 1570 -300 1570 -270 {
lab=VSS}
N 1550 -270 1570 -270 {
lab=VSS}
N 1580 150 1680 150 {
lab=Clk_2}
N 1570 -350 1670 -350 {
lab=Clk_1}
N 110 90 130 90 {
lab=#net12}
N 110 90 110 200 {
lab=#net12}
N 110 200 130 200 {
lab=#net12}
N 170 120 190 120 {
lab=#net13}
N 190 120 190 170 {
lab=#net13}
N 170 170 190 170 {
lab=#net13}
N 170 60 190 60 {
lab=VDD_1V8}
N 190 60 190 90 {
lab=VDD_1V8}
N 170 90 190 90 {
lab=VDD_1V8}
N 170 200 190 200 {
lab=VSS}
N 190 200 190 230 {
lab=VSS}
N 170 230 190 230 {
lab=VSS}
N 90 140 110 140 {
lab=#net12}
N 180 -240 340 -240 {
lab=#net4}
N 290 270 440 270 {
lab=#net7}
N 210 90 230 90 {
lab=#net13}
N 210 90 210 200 {
lab=#net13}
N 210 200 230 200 {
lab=#net13}
N 270 120 290 120 {
lab=#net14}
N 290 120 290 170 {
lab=#net14}
N 270 170 290 170 {
lab=#net14}
N 270 60 290 60 {
lab=VDD_1V8}
N 290 60 290 90 {
lab=VDD_1V8}
N 270 90 290 90 {
lab=VDD_1V8}
N 270 200 290 200 {
lab=VSS}
N 290 200 290 230 {
lab=VSS}
N 270 230 290 230 {
lab=VSS}
N 190 140 210 140 {
lab=#net13}
N 320 -410 340 -410 {
lab=#net10}
N 320 -410 320 -300 {
lab=#net10}
N 320 -300 340 -300 {
lab=#net10}
N 380 -380 400 -380 {
lab=#net15}
N 400 -380 400 -330 {
lab=#net15}
N 380 -330 400 -330 {
lab=#net15}
N 380 -440 400 -440 {
lab=VDD_1V8}
N 400 -440 400 -410 {
lab=VDD_1V8}
N 380 -410 400 -410 {
lab=VDD_1V8}
N 380 -300 400 -300 {
lab=VSS}
N 400 -300 400 -270 {
lab=VSS}
N 380 -270 400 -270 {
lab=VSS}
N 300 -360 320 -360 {
lab=#net10}
N 340 -240 370 -240 {
lab=#net4}
N 420 -410 440 -410 {
lab=#net15}
N 420 -410 420 -300 {
lab=#net15}
N 420 -300 440 -300 {
lab=#net15}
N 480 -380 500 -380 {
lab=#net16}
N 500 -380 500 -330 {
lab=#net16}
N 480 -330 500 -330 {
lab=#net16}
N 480 -440 500 -440 {
lab=VDD_1V8}
N 500 -440 500 -410 {
lab=VDD_1V8}
N 480 -410 500 -410 {
lab=VDD_1V8}
N 480 -300 500 -300 {
lab=VSS}
N 500 -300 500 -270 {
lab=VSS}
N 480 -270 500 -270 {
lab=VSS}
N 520 -410 540 -410 {
lab=#net16}
N 520 -410 520 -300 {
lab=#net16}
N 520 -300 540 -300 {
lab=#net16}
N 580 -380 600 -380 {
lab=#net17}
N 600 -380 600 -330 {
lab=#net17}
N 580 -330 600 -330 {
lab=#net17}
N 580 -440 600 -440 {
lab=VDD_1V8}
N 600 -440 600 -410 {
lab=VDD_1V8}
N 580 -410 600 -410 {
lab=VDD_1V8}
N 580 -300 600 -300 {
lab=VSS}
N 600 -300 600 -270 {
lab=VSS}
N 580 -270 600 -270 {
lab=VSS}
N 500 -360 520 -360 {
lab=#net16}
N 400 -360 420 -360 {
lab=#net15}
N 320 110 340 110 {
lab=#net14}
N 320 110 320 220 {
lab=#net14}
N 320 220 340 220 {
lab=#net14}
N 380 140 400 140 {
lab=#net18}
N 400 140 400 190 {
lab=#net18}
N 380 190 400 190 {
lab=#net18}
N 380 80 400 80 {
lab=VDD_1V8}
N 400 80 400 110 {
lab=VDD_1V8}
N 380 110 400 110 {
lab=VDD_1V8}
N 380 220 400 220 {
lab=VSS}
N 400 220 400 250 {
lab=VSS}
N 380 250 400 250 {
lab=VSS}
N 290 160 320 160 {
lab=#net14}
N 420 110 440 110 {
lab=#net18}
N 420 110 420 220 {
lab=#net18}
N 420 220 440 220 {
lab=#net18}
N 480 140 500 140 {
lab=#net19}
N 500 140 500 190 {
lab=#net19}
N 480 190 500 190 {
lab=#net19}
N 480 80 500 80 {
lab=VDD_1V8}
N 500 80 500 110 {
lab=VDD_1V8}
N 480 110 500 110 {
lab=VDD_1V8}
N 480 220 500 220 {
lab=VSS}
N 500 220 500 250 {
lab=VSS}
N 480 250 500 250 {
lab=VSS}
N 400 160 420 160 {
lab=#net18}
N 370 -240 540 -240 {
lab=#net4}
N 440 270 560 270 {
lab=#net7}
N 630 -410 650 -410 {
lab=#net17}
N 630 -410 630 -300 {
lab=#net17}
N 630 -300 650 -300 {
lab=#net17}
N 690 -380 710 -380 {
lab=#net20}
N 710 -380 710 -330 {
lab=#net20}
N 690 -330 710 -330 {
lab=#net20}
N 690 -440 710 -440 {
lab=VDD_1V8}
N 710 -440 710 -410 {
lab=VDD_1V8}
N 690 -410 710 -410 {
lab=VDD_1V8}
N 690 -300 710 -300 {
lab=VSS}
N 710 -300 710 -270 {
lab=VSS}
N 690 -270 710 -270 {
lab=VSS}
N 600 -360 630 -360 {
lab=#net17}
N 730 -410 750 -410 {
lab=#net20}
N 730 -410 730 -300 {
lab=#net20}
N 730 -300 750 -300 {
lab=#net20}
N 790 -380 810 -380 {
lab=#net21}
N 810 -380 810 -330 {
lab=#net21}
N 790 -330 810 -330 {
lab=#net21}
N 790 -440 810 -440 {
lab=VDD_1V8}
N 810 -440 810 -410 {
lab=VDD_1V8}
N 790 -410 810 -410 {
lab=VDD_1V8}
N 790 -300 810 -300 {
lab=VSS}
N 810 -300 810 -270 {
lab=VSS}
N 790 -270 810 -270 {
lab=VSS}
N 710 -360 730 -360 {
lab=#net20}
N 830 -410 850 -410 {
lab=#net21}
N 830 -410 830 -300 {
lab=#net21}
N 830 -300 850 -300 {
lab=#net21}
N 890 -380 910 -380 {
lab=#net22}
N 910 -380 910 -330 {
lab=#net22}
N 890 -330 910 -330 {
lab=#net22}
N 890 -440 910 -440 {
lab=VDD_1V8}
N 910 -440 910 -410 {
lab=VDD_1V8}
N 890 -410 910 -410 {
lab=VDD_1V8}
N 890 -300 910 -300 {
lab=VSS}
N 910 -300 910 -270 {
lab=VSS}
N 890 -270 910 -270 {
lab=VSS}
N 930 -410 950 -410 {
lab=#net22}
N 930 -410 930 -300 {
lab=#net22}
N 930 -300 950 -300 {
lab=#net22}
N 990 -380 1010 -380 {
lab=#net23}
N 1010 -380 1010 -330 {
lab=#net23}
N 990 -330 1010 -330 {
lab=#net23}
N 990 -440 1010 -440 {
lab=VDD_1V8}
N 1010 -440 1010 -410 {
lab=VDD_1V8}
N 990 -410 1010 -410 {
lab=VDD_1V8}
N 990 -300 1010 -300 {
lab=VSS}
N 1010 -300 1010 -270 {
lab=VSS}
N 990 -270 1010 -270 {
lab=VSS}
N 910 -360 930 -360 {
lab=#net22}
N 810 -360 830 -360 {
lab=#net21}
N 220 -410 240 -410 {
lab=#net9}
N 220 -410 220 -300 {
lab=#net9}
N 220 -300 240 -300 {
lab=#net9}
N 280 -380 300 -380 {
lab=#net10}
N 300 -380 300 -330 {
lab=#net10}
N 280 -330 300 -330 {
lab=#net10}
N 280 -440 300 -440 {
lab=VDD_1V8}
N 300 -440 300 -410 {
lab=VDD_1V8}
N 280 -410 300 -410 {
lab=VDD_1V8}
N 280 -300 300 -300 {
lab=VSS}
N 300 -300 300 -270 {
lab=VSS}
N 280 -270 300 -270 {
lab=VSS}
N 190 -360 220 -360 {
lab=#net9}
N 320 -410 340 -410 {
lab=#net10}
N 320 -410 320 -300 {
lab=#net10}
N 320 -300 340 -300 {
lab=#net10}
N 380 -380 400 -380 {
lab=#net15}
N 400 -380 400 -330 {
lab=#net15}
N 380 -330 400 -330 {
lab=#net15}
N 380 -440 400 -440 {
lab=VDD_1V8}
N 400 -440 400 -410 {
lab=VDD_1V8}
N 380 -410 400 -410 {
lab=VDD_1V8}
N 380 -300 400 -300 {
lab=VSS}
N 400 -300 400 -270 {
lab=VSS}
N 380 -270 400 -270 {
lab=VSS}
N 300 -360 320 -360 {
lab=#net10}
N 420 -410 440 -410 {
lab=#net15}
N 420 -410 420 -300 {
lab=#net15}
N 420 -300 440 -300 {
lab=#net15}
N 480 -380 500 -380 {
lab=#net16}
N 500 -380 500 -330 {
lab=#net16}
N 480 -330 500 -330 {
lab=#net16}
N 480 -440 500 -440 {
lab=VDD_1V8}
N 500 -440 500 -410 {
lab=VDD_1V8}
N 480 -410 500 -410 {
lab=VDD_1V8}
N 480 -300 500 -300 {
lab=VSS}
N 500 -300 500 -270 {
lab=VSS}
N 480 -270 500 -270 {
lab=VSS}
N 520 -410 540 -410 {
lab=#net16}
N 520 -410 520 -300 {
lab=#net16}
N 520 -300 540 -300 {
lab=#net16}
N 580 -380 600 -380 {
lab=#net17}
N 600 -380 600 -330 {
lab=#net17}
N 580 -330 600 -330 {
lab=#net17}
N 580 -440 600 -440 {
lab=VDD_1V8}
N 600 -440 600 -410 {
lab=VDD_1V8}
N 580 -410 600 -410 {
lab=VDD_1V8}
N 580 -300 600 -300 {
lab=VSS}
N 600 -300 600 -270 {
lab=VSS}
N 580 -270 600 -270 {
lab=VSS}
N 500 -360 520 -360 {
lab=#net16}
N 400 -360 420 -360 {
lab=#net15}
N 1040 -410 1060 -410 {
lab=#net23}
N 1040 -410 1040 -300 {
lab=#net23}
N 1040 -300 1060 -300 {
lab=#net23}
N 1100 -380 1120 -380 {
lab=#net24}
N 1120 -380 1120 -330 {
lab=#net24}
N 1100 -330 1120 -330 {
lab=#net24}
N 1100 -440 1120 -440 {
lab=VDD_1V8}
N 1120 -440 1120 -410 {
lab=VDD_1V8}
N 1100 -410 1120 -410 {
lab=VDD_1V8}
N 1100 -300 1120 -300 {
lab=VSS}
N 1120 -300 1120 -270 {
lab=VSS}
N 1100 -270 1120 -270 {
lab=VSS}
N 1010 -360 1040 -360 {
lab=#net23}
N 1140 -410 1160 -410 {
lab=#net24}
N 1140 -410 1140 -300 {
lab=#net24}
N 1140 -300 1160 -300 {
lab=#net24}
N 1200 -380 1220 -380 {
lab=#net25}
N 1220 -380 1220 -330 {
lab=#net25}
N 1200 -330 1220 -330 {
lab=#net25}
N 1200 -440 1220 -440 {
lab=VDD_1V8}
N 1220 -440 1220 -410 {
lab=VDD_1V8}
N 1200 -410 1220 -410 {
lab=VDD_1V8}
N 1200 -300 1220 -300 {
lab=VSS}
N 1220 -300 1220 -270 {
lab=VSS}
N 1200 -270 1220 -270 {
lab=VSS}
N 1120 -360 1140 -360 {
lab=#net24}
N 1240 -410 1260 -410 {
lab=#net25}
N 1240 -410 1240 -300 {
lab=#net25}
N 1240 -300 1260 -300 {
lab=#net25}
N 1300 -380 1320 -380 {
lab=#net26}
N 1320 -380 1320 -330 {
lab=#net26}
N 1300 -330 1320 -330 {
lab=#net26}
N 1300 -440 1320 -440 {
lab=VDD_1V8}
N 1320 -440 1320 -410 {
lab=VDD_1V8}
N 1300 -410 1320 -410 {
lab=VDD_1V8}
N 1300 -300 1320 -300 {
lab=VSS}
N 1320 -300 1320 -270 {
lab=VSS}
N 1300 -270 1320 -270 {
lab=VSS}
N 1340 -410 1360 -410 {
lab=#net26}
N 1340 -410 1340 -300 {
lab=#net26}
N 1340 -300 1360 -300 {
lab=#net26}
N 1400 -380 1420 -380 {
lab=#net7}
N 1420 -380 1420 -330 {
lab=#net7}
N 1400 -330 1420 -330 {
lab=#net7}
N 1400 -440 1420 -440 {
lab=VDD_1V8}
N 1420 -440 1420 -410 {
lab=VDD_1V8}
N 1400 -410 1420 -410 {
lab=VDD_1V8}
N 1400 -300 1420 -300 {
lab=VSS}
N 1420 -300 1420 -270 {
lab=VSS}
N 1400 -270 1420 -270 {
lab=VSS}
N 1320 -360 1340 -360 {
lab=#net26}
N 1220 -360 1240 -360 {
lab=#net25}
N 1420 -350 1490 -350 {
lab=#net7}
N 530 110 550 110 {
lab=#net19}
N 530 110 530 220 {
lab=#net19}
N 530 220 550 220 {
lab=#net19}
N 590 140 610 140 {
lab=#net27}
N 610 140 610 190 {
lab=#net27}
N 590 190 610 190 {
lab=#net27}
N 590 80 610 80 {
lab=VDD_1V8}
N 610 80 610 110 {
lab=VDD_1V8}
N 590 110 610 110 {
lab=VDD_1V8}
N 590 220 610 220 {
lab=VSS}
N 610 220 610 250 {
lab=VSS}
N 590 250 610 250 {
lab=VSS}
N 500 160 530 160 {
lab=#net19}
N 630 110 650 110 {
lab=#net27}
N 630 110 630 220 {
lab=#net27}
N 630 220 650 220 {
lab=#net27}
N 690 140 710 140 {
lab=#net28}
N 710 140 710 190 {
lab=#net28}
N 690 190 710 190 {
lab=#net28}
N 690 80 710 80 {
lab=VDD_1V8}
N 710 80 710 110 {
lab=VDD_1V8}
N 690 110 710 110 {
lab=VDD_1V8}
N 690 220 710 220 {
lab=VSS}
N 710 220 710 250 {
lab=VSS}
N 690 250 710 250 {
lab=VSS}
N 610 160 630 160 {
lab=#net27}
N 730 110 750 110 {
lab=#net28}
N 730 110 730 220 {
lab=#net28}
N 730 220 750 220 {
lab=#net28}
N 790 140 810 140 {
lab=#net29}
N 810 140 810 190 {
lab=#net29}
N 790 190 810 190 {
lab=#net29}
N 790 80 810 80 {
lab=VDD_1V8}
N 810 80 810 110 {
lab=VDD_1V8}
N 790 110 810 110 {
lab=VDD_1V8}
N 790 220 810 220 {
lab=VSS}
N 810 220 810 250 {
lab=VSS}
N 790 250 810 250 {
lab=VSS}
N 830 110 850 110 {
lab=#net29}
N 830 110 830 220 {
lab=#net29}
N 830 220 850 220 {
lab=#net29}
N 890 140 910 140 {
lab=#net30}
N 910 140 910 190 {
lab=#net30}
N 890 190 910 190 {
lab=#net30}
N 890 80 910 80 {
lab=VDD_1V8}
N 910 80 910 110 {
lab=VDD_1V8}
N 890 110 910 110 {
lab=VDD_1V8}
N 890 220 910 220 {
lab=VSS}
N 910 220 910 250 {
lab=VSS}
N 890 250 910 250 {
lab=VSS}
N 810 160 830 160 {
lab=#net29}
N 710 160 730 160 {
lab=#net28}
N 940 110 960 110 {
lab=#net30}
N 940 110 940 220 {
lab=#net30}
N 940 220 960 220 {
lab=#net30}
N 1000 140 1020 140 {
lab=#net31}
N 1020 140 1020 190 {
lab=#net31}
N 1000 190 1020 190 {
lab=#net31}
N 1000 80 1020 80 {
lab=VDD_1V8}
N 1020 80 1020 110 {
lab=VDD_1V8}
N 1000 110 1020 110 {
lab=VDD_1V8}
N 1000 220 1020 220 {
lab=VSS}
N 1020 220 1020 250 {
lab=VSS}
N 1000 250 1020 250 {
lab=VSS}
N 910 160 940 160 {
lab=#net30}
N 1040 110 1060 110 {
lab=#net31}
N 1040 110 1040 220 {
lab=#net31}
N 1040 220 1060 220 {
lab=#net31}
N 1100 140 1120 140 {
lab=#net32}
N 1120 140 1120 190 {
lab=#net32}
N 1100 190 1120 190 {
lab=#net32}
N 1100 80 1120 80 {
lab=VDD_1V8}
N 1120 80 1120 110 {
lab=VDD_1V8}
N 1100 110 1120 110 {
lab=VDD_1V8}
N 1100 220 1120 220 {
lab=VSS}
N 1120 220 1120 250 {
lab=VSS}
N 1100 250 1120 250 {
lab=VSS}
N 1020 160 1040 160 {
lab=#net31}
N 1140 110 1160 110 {
lab=#net32}
N 1140 110 1140 220 {
lab=#net32}
N 1140 220 1160 220 {
lab=#net32}
N 1200 140 1220 140 {
lab=#net33}
N 1220 140 1220 190 {
lab=#net33}
N 1200 190 1220 190 {
lab=#net33}
N 1200 80 1220 80 {
lab=VDD_1V8}
N 1220 80 1220 110 {
lab=VDD_1V8}
N 1200 110 1220 110 {
lab=VDD_1V8}
N 1200 220 1220 220 {
lab=VSS}
N 1220 220 1220 250 {
lab=VSS}
N 1200 250 1220 250 {
lab=VSS}
N 1240 110 1260 110 {
lab=#net33}
N 1240 110 1240 220 {
lab=#net33}
N 1240 220 1260 220 {
lab=#net33}
N 1300 140 1320 140 {
lab=#net4}
N 1320 140 1320 190 {
lab=#net4}
N 1300 190 1320 190 {
lab=#net4}
N 1300 80 1320 80 {
lab=VDD_1V8}
N 1320 80 1320 110 {
lab=VDD_1V8}
N 1300 110 1320 110 {
lab=VDD_1V8}
N 1300 220 1320 220 {
lab=VSS}
N 1320 220 1320 250 {
lab=VSS}
N 1300 250 1320 250 {
lab=VSS}
N 1220 160 1240 160 {
lab=#net33}
N 1120 160 1140 160 {
lab=#net32}
N 1320 170 1500 170 {
lab=#net4}
N 540 -240 1400 -240 {
lab=#net4}
N 1400 -240 1400 170 {
lab=#net4}
N 560 270 1460 270 {
lab=#net7}
N 1460 -340 1460 270 {
lab=#net7}
N 1460 -350 1460 -340 {
lab=#net7}
C {devices/ipin.sym} -670 -470 0 0 {name=p3 lab=VDD_1V8}
C {devices/ipin.sym} -730 410 0 0 {name=p4 lab=VSS}
C {devices/ipin.sym} -710 -400 0 0 {name=p6 lab=Clk}
C {cborder/border_s.sym} 440 290 0 0 {
user="wulff"
company="wulff"}
C {devices/lab_wire.sym} -670 410 0 1 {name=p11 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 1670 -350 0 0 {name=p1 lab=Clk_1
}
C {devices/opin.sym} 1680 150 0 0 {name=p2 lab=Clk_2}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -650 -80 0 0 {name=x1 }
C {devices/lab_wire.sym} -590 -220 0 1 {name=p5 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} -620 -470 0 1 {name=p7 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -650 -190 0 0 {name=x14 }
C {devices/lab_wire.sym} -590 -50 0 1 {name=p8 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -290 -420 0 1 {name=x2 }
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -450 -420 0 0 {name=x3 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -410 -330 0 0 {name=x4 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -330 -240 0 1 {name=x5 }
C {devices/lab_wire.sym} -390 -210 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -370 -470 0 1 {name=p10 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -290 90 0 1 {name=x6 }
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -450 90 0 0 {name=x7 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -410 180 0 0 {name=x8 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -330 270 0 1 {name=x9 }
C {devices/lab_wire.sym} -390 300 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -370 40 0 1 {name=p13 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -120 -320 0 0 {name=x10 }
C {devices/lab_wire.sym} -60 -460 0 1 {name=p14 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -120 -430 0 0 {name=x11 }
C {devices/lab_wire.sym} -60 -290 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 60 -310 0 0 {name=x12 }
C {devices/lab_wire.sym} 120 -450 0 1 {name=p16 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 60 -420 0 0 {name=x13 }
C {devices/lab_wire.sym} 120 -280 0 1 {name=p17 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 240 -300 0 0 {name=x15 }
C {devices/lab_wire.sym} 300 -440 0 1 {name=p18 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 240 -410 0 0 {name=x16 }
C {devices/lab_wire.sym} 300 -270 0 1 {name=p19 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -150 190 0 0 {name=x17 }
C {devices/lab_wire.sym} -90 50 0 1 {name=p20 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -150 80 0 0 {name=x18 }
C {devices/lab_wire.sym} -90 220 0 1 {name=p21 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 30 200 0 0 {name=x19 }
C {devices/lab_wire.sym} 90 60 0 1 {name=p22 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 30 90 0 0 {name=x20 }
C {devices/lab_wire.sym} 90 230 0 1 {name=p23 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1520 210 0 0 {name=x21 }
C {devices/lab_wire.sym} 1580 70 0 1 {name=p24 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1580 240 0 1 {name=p25 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1510 -300 0 0 {name=x25 }
C {devices/lab_wire.sym} 1570 -440 0 1 {name=p28 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1510 -410 0 0 {name=x26 }
C {devices/lab_wire.sym} 1570 -270 0 1 {name=p29 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1520 100 0 0 {name=x22 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 130 200 0 0 {name=x23 }
C {devices/lab_wire.sym} 190 60 0 1 {name=p26 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 190 230 0 1 {name=p27 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 130 90 0 0 {name=x24 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 230 200 0 0 {name=x27 }
C {devices/lab_wire.sym} 290 60 0 1 {name=p30 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 290 230 0 1 {name=p31 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 230 90 0 0 {name=x28 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 340 -300 0 0 {name=x29 }
C {devices/lab_wire.sym} 400 -440 0 1 {name=p32 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 400 -270 0 1 {name=p33 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 340 -410 0 0 {name=x30 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 440 -300 0 0 {name=x31 }
C {devices/lab_wire.sym} 500 -440 0 1 {name=p34 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 440 -410 0 0 {name=x32 }
C {devices/lab_wire.sym} 500 -270 0 1 {name=p35 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 540 -300 0 0 {name=x33 }
C {devices/lab_wire.sym} 600 -440 0 1 {name=p36 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 600 -270 0 1 {name=p37 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 540 -410 0 0 {name=x34 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 340 220 0 0 {name=x35 }
C {devices/lab_wire.sym} 400 80 0 1 {name=p38 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 340 110 0 0 {name=x36 }
C {devices/lab_wire.sym} 400 250 0 1 {name=p39 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 440 220 0 0 {name=x37 }
C {devices/lab_wire.sym} 500 80 0 1 {name=p40 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 500 250 0 1 {name=p41 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 440 110 0 0 {name=x38 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 650 -300 0 0 {name=x39 }
C {devices/lab_wire.sym} 710 -440 0 1 {name=p42 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 650 -410 0 0 {name=x40 }
C {devices/lab_wire.sym} 710 -270 0 1 {name=p43 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 750 -300 0 0 {name=x41 }
C {devices/lab_wire.sym} 810 -440 0 1 {name=p44 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 810 -270 0 1 {name=p45 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 750 -410 0 0 {name=x42 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 850 -300 0 0 {name=x43 }
C {devices/lab_wire.sym} 910 -440 0 1 {name=p46 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 850 -410 0 0 {name=x44 }
C {devices/lab_wire.sym} 910 -270 0 1 {name=p47 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 950 -300 0 0 {name=x45 }
C {devices/lab_wire.sym} 1010 -440 0 1 {name=p48 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1010 -270 0 1 {name=p49 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 950 -410 0 0 {name=x46 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 240 -300 0 0 {name=x47 }
C {devices/lab_wire.sym} 300 -440 0 1 {name=p50 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 240 -410 0 0 {name=x48 }
C {devices/lab_wire.sym} 300 -270 0 1 {name=p51 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 340 -300 0 0 {name=x49 }
C {devices/lab_wire.sym} 400 -440 0 1 {name=p52 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 400 -270 0 1 {name=p53 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 340 -410 0 0 {name=x50 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 440 -300 0 0 {name=x51 }
C {devices/lab_wire.sym} 500 -440 0 1 {name=p54 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 440 -410 0 0 {name=x52 }
C {devices/lab_wire.sym} 500 -270 0 1 {name=p55 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 540 -300 0 0 {name=x53 }
C {devices/lab_wire.sym} 600 -440 0 1 {name=p56 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 600 -270 0 1 {name=p57 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 540 -410 0 0 {name=x54 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1060 -300 0 0 {name=x55 }
C {devices/lab_wire.sym} 1120 -440 0 1 {name=p58 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1060 -410 0 0 {name=x56 }
C {devices/lab_wire.sym} 1120 -270 0 1 {name=p59 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1160 -300 0 0 {name=x57 }
C {devices/lab_wire.sym} 1220 -440 0 1 {name=p60 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1220 -270 0 1 {name=p61 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1160 -410 0 0 {name=x58 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1260 -300 0 0 {name=x59 }
C {devices/lab_wire.sym} 1320 -440 0 1 {name=p62 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1260 -410 0 0 {name=x60 }
C {devices/lab_wire.sym} 1320 -270 0 1 {name=p63 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1360 -300 0 0 {name=x61 }
C {devices/lab_wire.sym} 1420 -440 0 1 {name=p64 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1420 -270 0 1 {name=p65 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1360 -410 0 0 {name=x62 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 550 220 0 0 {name=x63 }
C {devices/lab_wire.sym} 610 80 0 1 {name=p66 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 550 110 0 0 {name=x64 }
C {devices/lab_wire.sym} 610 250 0 1 {name=p67 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 650 220 0 0 {name=x65 }
C {devices/lab_wire.sym} 710 80 0 1 {name=p68 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 710 250 0 1 {name=p69 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 650 110 0 0 {name=x66 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 750 220 0 0 {name=x67 }
C {devices/lab_wire.sym} 810 80 0 1 {name=p70 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 750 110 0 0 {name=x68 }
C {devices/lab_wire.sym} 810 250 0 1 {name=p71 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 850 220 0 0 {name=x69 }
C {devices/lab_wire.sym} 910 80 0 1 {name=p72 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 910 250 0 1 {name=p73 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 850 110 0 0 {name=x70 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 960 220 0 0 {name=x71 }
C {devices/lab_wire.sym} 1020 80 0 1 {name=p74 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 960 110 0 0 {name=x72 }
C {devices/lab_wire.sym} 1020 250 0 1 {name=p75 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1060 220 0 0 {name=x73 }
C {devices/lab_wire.sym} 1120 80 0 1 {name=p76 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1120 250 0 1 {name=p77 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1060 110 0 0 {name=x74 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1160 220 0 0 {name=x75 }
C {devices/lab_wire.sym} 1220 80 0 1 {name=p78 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1160 110 0 0 {name=x76 }
C {devices/lab_wire.sym} 1220 250 0 1 {name=p79 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 1260 220 0 0 {name=x77 }
C {devices/lab_wire.sym} 1320 80 0 1 {name=p80 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} 1320 250 0 1 {name=p81 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 1260 110 0 0 {name=x78 }
