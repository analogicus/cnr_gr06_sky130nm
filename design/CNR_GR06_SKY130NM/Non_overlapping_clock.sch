v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {Non overlapping clock} -280 -580 0 0 1 1 {}
N -670 -470 -620 -470 {
lab=VDD_1V8}
N -730 410 -670 410 {
lab=VSS}
N -670 -190 -650 -190 {
lab=Clk}
N -670 -190 -670 -80 {
lab=Clk}
N -670 -80 -650 -80 {
lab=Clk}
N -610 -160 -590 -160 {
lab=#net1}
N -590 -160 -590 -110 {
lab=#net1}
N -610 -110 -590 -110 {
lab=#net1}
N -610 -220 -590 -220 {
lab=VDD_1V8}
N -590 -220 -590 -190 {
lab=VDD_1V8}
N -610 -190 -590 -190 {
lab=VDD_1V8}
N -610 -80 -590 -80 {
lab=VSS}
N -590 -80 -590 -50 {
lab=VSS}
N -610 -50 -590 -50 {
lab=VSS}
N -410 -390 -330 -390 {
lab=#net2}
N -370 -390 -370 -360 {
lab=#net2}
N -370 -300 -370 -270 {
lab=#net3}
N -390 -240 -370 -240 {
lab=VSS}
N -390 -240 -390 -210 {
lab=VSS}
N -390 -210 -370 -210 {
lab=VSS}
N -370 -330 -350 -330 {
lab=#net3}
N -350 -330 -350 -290 {
lab=#net3}
N -370 -290 -350 -290 {
lab=#net3}
N -410 -450 -330 -450 {
lab=VDD_1V8}
N -410 -420 -330 -420 {
lab=VDD_1V8}
N -410 -420 -370 -420 {
lab=VDD_1V8}
N -370 -450 -370 -420 {
lab=VDD_1V8}
N -370 -470 -370 -450 {
lab=VDD_1V8}
N -330 -240 -210 -240 {
lab=#net4}
N -290 -420 -280 -420 {
lab=#net4}
N -280 -420 -280 -240 {
lab=#net4}
N -370 -380 -200 -380 {
lab=#net2}
N -470 -420 -450 -420 {
lab=Clk}
N -470 -420 -470 -330 {
lab=Clk}
N -470 -330 -410 -330 {
lab=Clk}
N -520 -400 -470 -400 {
lab=Clk}
N -710 -400 -520 -400 {
lab=Clk}
N -700 -400 -700 -140 {
lab=Clk}
N -700 -140 -670 -140 {
lab=Clk}
N -410 120 -330 120 {
lab=#net5}
N -370 120 -370 150 {
lab=#net5}
N -370 210 -370 240 {
lab=#net6}
N -390 270 -370 270 {
lab=VSS}
N -390 270 -390 300 {
lab=VSS}
N -390 300 -370 300 {
lab=VSS}
N -370 180 -350 180 {
lab=#net6}
N -350 180 -350 220 {
lab=#net6}
N -370 220 -350 220 {
lab=#net6}
N -410 60 -330 60 {
lab=VDD_1V8}
N -410 90 -330 90 {
lab=VDD_1V8}
N -410 90 -370 90 {
lab=VDD_1V8}
N -370 60 -370 90 {
lab=VDD_1V8}
N -370 40 -370 60 {
lab=VDD_1V8}
N -330 270 -210 270 {
lab=#net7}
N -290 90 -280 90 {
lab=#net7}
N -280 90 -280 270 {
lab=#net7}
N -370 130 -200 130 {
lab=#net5}
N -470 90 -450 90 {
lab=#net1}
N -470 90 -470 180 {
lab=#net1}
N -470 180 -410 180 {
lab=#net1}
N -590 -130 -520 -130 {
lab=#net1}
N -520 -130 -520 140 {
lab=#net1}
N -520 140 -470 140 {
lab=#net1}
N -140 -430 -120 -430 {
lab=#net2}
N -140 -430 -140 -320 {
lab=#net2}
N -140 -320 -120 -320 {
lab=#net2}
N -80 -400 -60 -400 {
lab=#net8}
N -60 -400 -60 -350 {
lab=#net8}
N -80 -350 -60 -350 {
lab=#net8}
N -80 -460 -60 -460 {
lab=VDD_1V8}
N -60 -460 -60 -430 {
lab=VDD_1V8}
N -80 -430 -60 -430 {
lab=VDD_1V8}
N -80 -320 -60 -320 {
lab=VSS}
N -60 -320 -60 -290 {
lab=VSS}
N -80 -290 -60 -290 {
lab=VSS}
N -170 -380 -140 -380 {
lab=#net2}
N -60 -370 10 -370 {
lab=#net8}
N 40 -420 60 -420 {
lab=#net8}
N 40 -420 40 -310 {
lab=#net8}
N 40 -310 60 -310 {
lab=#net8}
N 100 -390 120 -390 {
lab=#net7}
N 120 -390 120 -340 {
lab=#net7}
N 100 -340 120 -340 {
lab=#net7}
N 100 -450 120 -450 {
lab=VDD_1V8}
N 120 -450 120 -420 {
lab=VDD_1V8}
N 100 -420 120 -420 {
lab=VDD_1V8}
N 100 -310 120 -310 {
lab=VSS}
N 120 -310 120 -280 {
lab=VSS}
N 100 -280 120 -280 {
lab=VSS}
N 10 -370 40 -370 {
lab=#net8}
N 120 -360 190 -360 {
lab=#net7}
N 450 -410 470 -410 {
lab=#net7}
N 450 -410 450 -300 {
lab=#net7}
N 450 -300 470 -300 {
lab=#net7}
N 510 -380 530 -380 {
lab=Clk_1}
N 530 -380 530 -330 {
lab=Clk_1}
N 510 -330 530 -330 {
lab=Clk_1}
N 510 -440 530 -440 {
lab=VDD_1V8}
N 530 -440 530 -410 {
lab=VDD_1V8}
N 510 -410 530 -410 {
lab=VDD_1V8}
N 510 -300 530 -300 {
lab=VSS}
N 530 -300 530 -270 {
lab=VSS}
N 510 -270 530 -270 {
lab=VSS}
N 420 -360 450 -360 {
lab=#net7}
N 530 -350 600 -350 {
lab=Clk_1}
N -170 80 -150 80 {
lab=#net5}
N -170 80 -170 190 {
lab=#net5}
N -170 190 -150 190 {
lab=#net5}
N -110 110 -90 110 {
lab=#net9}
N -90 110 -90 160 {
lab=#net9}
N -110 160 -90 160 {
lab=#net9}
N -110 50 -90 50 {
lab=VDD_1V8}
N -90 50 -90 80 {
lab=VDD_1V8}
N -110 80 -90 80 {
lab=VDD_1V8}
N -110 190 -90 190 {
lab=VSS}
N -90 190 -90 220 {
lab=VSS}
N -110 220 -90 220 {
lab=VSS}
N -200 130 -170 130 {
lab=#net5}
N -90 140 -20 140 {
lab=#net9}
N 10 90 30 90 {
lab=#net9}
N 10 90 10 200 {
lab=#net9}
N 10 200 30 200 {
lab=#net9}
N 70 120 90 120 {
lab=#net4}
N 90 120 90 170 {
lab=#net4}
N 70 170 90 170 {
lab=#net4}
N 70 60 90 60 {
lab=VDD_1V8}
N 90 60 90 90 {
lab=VDD_1V8}
N 70 90 90 90 {
lab=VDD_1V8}
N 70 200 90 200 {
lab=VSS}
N 90 200 90 230 {
lab=VSS}
N 70 230 90 230 {
lab=VSS}
N -20 140 10 140 {
lab=#net9}
N 90 150 160 150 {
lab=#net4}
N 420 100 440 100 {
lab=#net4}
N 420 100 420 210 {
lab=#net4}
N 420 210 440 210 {
lab=#net4}
N 480 130 500 130 {
lab=Clk_2}
N 500 130 500 180 {
lab=Clk_2}
N 480 180 500 180 {
lab=Clk_2}
N 480 70 500 70 {
lab=VDD_1V8}
N 500 70 500 100 {
lab=VDD_1V8}
N 480 100 500 100 {
lab=VDD_1V8}
N 480 210 500 210 {
lab=VSS}
N 500 210 500 240 {
lab=VSS}
N 480 240 500 240 {
lab=VSS}
N 500 160 570 160 {
lab=Clk_2}
N -200 -380 -170 -380 {
lab=#net2}
N 190 -360 420 -360 {
lab=#net7}
N -210 270 290 270 {
lab=#net7}
N 290 -360 290 270 {
lab=#net7}
N 160 150 400 150 {
lab=#net4}
N 400 150 420 150 {
lab=#net4}
N -210 -240 180 -240 {
lab=#net4}
N 180 -240 180 150 {
lab=#net4}
N 570 160 750 160 {
lab=Clk_2}
N 600 -350 740 -350 {
lab=Clk_1}
C {devices/ipin.sym} -670 -470 0 0 {name=p3 lab=VDD_1V8}
C {devices/ipin.sym} -730 410 0 0 {name=p4 lab=VSS}
C {devices/ipin.sym} -710 -400 0 0 {name=p6 lab=Clk}
C {cborder/border_s.sym} 440 290 0 0 {
user="wulff"
company="wulff"}
C {devices/lab_wire.sym} -670 410 0 1 {name=p11 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 740 -350 0 0 {name=p1 lab=Clk_1
}
C {devices/opin.sym} 750 160 0 0 {name=p2 lab=Clk_2}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -650 -80 0 0 {name=x1 }
C {devices/lab_wire.sym} -590 -220 0 1 {name=p5 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_wire.sym} -620 -470 0 1 {name=p7 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -650 -190 0 0 {name=x14 }
C {devices/lab_wire.sym} -590 -50 0 1 {name=p8 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -290 -420 0 1 {name=x2 }
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -450 -420 0 0 {name=x3 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -410 -330 0 0 {name=x4 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -330 -240 0 1 {name=x5 }
C {devices/lab_wire.sym} -390 -210 0 0 {name=p9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -370 -470 0 1 {name=p10 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -290 90 0 1 {name=x6 }
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -450 90 0 0 {name=x7 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -410 180 0 0 {name=x8 }
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -330 270 0 1 {name=x9 }
C {devices/lab_wire.sym} -390 300 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} -370 40 0 1 {name=p13 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -120 -320 0 0 {name=x10 }
C {devices/lab_wire.sym} -60 -460 0 1 {name=p14 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -120 -430 0 0 {name=x11 }
C {devices/lab_wire.sym} -60 -290 0 1 {name=p15 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 60 -310 0 0 {name=x12 }
C {devices/lab_wire.sym} 120 -450 0 1 {name=p16 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 60 -420 0 0 {name=x13 }
C {devices/lab_wire.sym} 120 -280 0 1 {name=p17 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 470 -300 0 0 {name=x15 }
C {devices/lab_wire.sym} 530 -440 0 1 {name=p18 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 470 -410 0 0 {name=x16 }
C {devices/lab_wire.sym} 530 -270 0 1 {name=p19 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} -150 190 0 0 {name=x17 }
C {devices/lab_wire.sym} -90 50 0 1 {name=p20 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} -150 80 0 0 {name=x18 }
C {devices/lab_wire.sym} -90 220 0 1 {name=p21 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 30 200 0 0 {name=x19 }
C {devices/lab_wire.sym} 90 60 0 1 {name=p22 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 30 90 0 0 {name=x20 }
C {devices/lab_wire.sym} 90 230 0 1 {name=p23 sig_type=std_logic lab=VSS}
C {SUN_TR_SKY130NM/SUNTR_NCHLCM.sym} 440 210 0 0 {name=x21 }
C {devices/lab_wire.sym} 500 70 0 1 {name=p24 sig_type=std_logic lab=VDD_1V8}
C {SUN_TR_SKY130NM/SUNTR_PCHLCM.sym} 440 100 0 0 {name=x22 }
C {devices/lab_wire.sym} 500 240 0 1 {name=p25 sig_type=std_logic lab=VSS}
