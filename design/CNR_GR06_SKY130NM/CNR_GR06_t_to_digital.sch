v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {D = f(t)} -100 -450 0 0 1 1 {}
C {cborder/border_s.sym} 410 400 0 0 {
user="wulff"
company="wulff"}
C {devices/ipin.sym} -480 -250 0 0 {name=p1 lab=VDD_1V8
}
C {devices/ipin.sym} -480 400 0 0 {name=p2 lab=VSS
}
C {devices/ipin.sym} -480 -140 0 0 {name=p3 lab=Vo
}
C {devices/ipin.sym} -480 180 0 0 {name=p4 lab=Clock
}
C {devices/opin.sym} 560 -230 0 0 {name=p5 lab=Dout
}
