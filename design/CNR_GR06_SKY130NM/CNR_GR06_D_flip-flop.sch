v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {D flip-flop} -90 -530 0 0 1 1 {}
C {cborder/border_s.sym} 420 320 0 0 {
user="wulff"
company="wulff"}
